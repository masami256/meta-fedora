
inherit fedora-package
require recipes-fedora/sources/busybox.inc

